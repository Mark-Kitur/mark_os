FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-callibrate-Add-printk-example.patch"
SRC_URI += "file://gpio-sysfs.cfg"

