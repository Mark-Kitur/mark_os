# Fix buildpaths QA errors in elfutils ptest
INSANE_SKIP:${PN}-ptest += "buildpaths"
