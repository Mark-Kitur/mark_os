FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://psplash-marcos.ppm-img.h"

SPLASH_IMAGES = "file://psplash-marcos.ppm-img.h"