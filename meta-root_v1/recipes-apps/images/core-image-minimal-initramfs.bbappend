IMAGE_INSTALL:remove = "busybox glibc"
IMAGE_INSTALL:append = " busybox-static"


