require char-device.inc

PV = "1.2"